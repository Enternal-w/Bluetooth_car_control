# Keil uVision project KEY.uvprojx, settings and files
target KEY (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\..\LCD\HARDWARE\LCD;..\..\LCD\STM32F10x_FWLib\src;..\HARDWARE\TIMER;..\..\备份\最稳定的一版本\CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../../../../ALIENTEK/A/4，程序源码/2，标准例程-库函数版本/实验0-1 Template工程模板-新建工程章节使用/SYSTEM/usart/: usart.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
    ../../LCD/STM32F10x_FWLib/src/: stm32f10x_fsmc.c
  group README
    ../: README.TXT
    ./: readme.txt
  group CORE
    ../../备份/最稳定的一版本/CORE/: core_cm3.c startup_stm32f10x_hd.s
